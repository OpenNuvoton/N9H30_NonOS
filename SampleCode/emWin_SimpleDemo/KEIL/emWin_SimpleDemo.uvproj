# Keil uVision project emWin_SimpleDemo.uvproj, settings and files
target emWin_SimpleDemo (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: emWin_SimpleDemo
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c misc: --diag_suppress=550
  c include: ..\..\..\Driver\Source;..\..\..\Driver\Include;..\..\..\ThirdParty\FATFS\src;..\..\..\ThirdParty\emWin\Config;..\..\..\ThirdParty\emWin\Include;..\..\emWin_SimpleDemo;..\tslib;..\Application
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x80000 size 0x800000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H30.sct
  link misc: --entry 0
  group Libraries
    ../../../Driver/Source/: standalone.c sys.c sys_timer.c sys_uart.c gpio.c sdh.c lcd.c adc.c system_N9H30.c startup_N9H30.s sys_N9H30.s
  group FatFs
    ../../../ThirdParty/FATFS/src/: ff.c
  group tslib
    ../tslib/: fbutils.c font_8x8.c testutils.c TouchPanel.c ts_calibrate.c diskio.c SDGlue.c ts_test.c
  group emWin
    ../../../ThirdParty/emWin/Config/: GUI_X.c GUIConf.c LCDConf.c
    ../../../ThirdParty/emWin/Lib/: NUemWin_ARM9_Keil.lib
  group Application
    ../Application/: FramewinDLG.c
  group src
    ../: main.c
