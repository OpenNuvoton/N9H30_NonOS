# Keil uVision project RTOSDemo.uvproj, settings and files
target RTOSDemo_ARM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: RTOSDemo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: .\Startup;..\..\..\ThirdParty\FreeRTOSV9.0.0\FreeRTOS\Source\portable\RVDS\ARM9_N9H30;..\..\..\ThirdParty\FreeRTOSV9.0.0\FreeRTOS\Source\include;..\..\..\ThirdParty\FreeRTOSV9.0.0\FreeRTOS\Demo\Common\include;..\..\..\Driver\Include
  asm include: ..\..\..\ThirdParty\FreeRTOSV9.0.0\FreeRTOS\Source\portable\RVDS\ARM9_N9H30
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H30.sct
  link misc: --entry 0
  group Startup
    ./Startup/: multithread.c main.c startup.s standalone.c
  group Stadard Demo
    ./Demo/: BlockQ.c dynamic.c PollQ.c semtest.c
  group Lib
    ../../../Driver/Source/: sys.c sys_uart.c system_N9H30.c sys_N9H30.s
  group FreeRTOS
    ../../../ThirdParty/FreeRTOSV9.0.0/FreeRTOS/Source/: tasks.c list.c queue.c
    ../../../ThirdParty/FreeRTOSV9.0.0/FreeRTOS/Source/portable/RVDS/ARM9_N9H30/: port.c portASM.s
    ../../../ThirdParty/FreeRTOSV9.0.0/FreeRTOS/Source/portable/MemMang/: heap_2.c
